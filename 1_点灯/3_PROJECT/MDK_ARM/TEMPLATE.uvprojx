# Keil uVision project TEMPLATE.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMPLATE +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\..\2_DRIVE;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\0_CORE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../../0_CORE/: startup_stm32f10x_hd.s
  group USER
    ../: main.c
  group DRIVE
    ../../2_DRIVE/: led.c key.c
  group SYSTEM
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/usart/: usart.c
