# Keil uVision project TEMPLATE.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMPLATE
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\0_CORE;..\..\1_FWLIB_3_5_0\inc;..\..\3_PROJECT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../../0_CORE/: core_cm3.h startup_stm32f10x_md.s
  group USER
    ../: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB_3_5_0
    ../../1_FWLIB_3_5_0/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c
  group DRIVE
    ../../2_DRIVE/: delay.c
